<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Board-GW0011\Board-GW0011.xml</path>
  </project>
  <project>
    <path>$WS_DIR$\Board-GW0015\Board-GW0015.xml</path>
  </project>
  <project>
    <path>$WS_DIR$\GW0015-AC\GW0015-AC.xml</path>
  </project>
   <project>
    <path>$WS_DIR$\GW0015-CC\GW0015-CC.xml</path>
  </project>
  <batchBuild/>
</workspace>


