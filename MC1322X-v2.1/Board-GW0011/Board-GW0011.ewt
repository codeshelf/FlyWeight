<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>FlyWeight</name>
      <file>
        <name>$PROJ_DIR$\..\..\src\commands.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\commandTypes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\deviceInfoPFC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\deviceQuery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\mainPFC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\pfcSPITask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\radioCommon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\remoteCommon.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\remoteMgmtTask.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\remoteRadioTaskSMAC2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\smacPort.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\src\ulaw.c</name>
      </file>
    </group>
    <group>
      <name>Otap</name>
    </group>
    <group>
      <name>Utilities</name>
      <file>
        <name>$PROJ_DIR$\Utilities\Display.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Utilities\Keyboard.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Utilities\Leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Utilities\Sound.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Utilities\UartUtil.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\src\FreeRTOSConfig.h</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS</name>
    <group>
      <name>Source</name>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\croutine.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\FreeRTOS.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\list.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\portable.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\projdefs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\queue.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\semphr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\StackMacros.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\include\task.h</name>
        </file>
      </group>
      <group>
        <name>portable</name>
        <group>
          <name>IAR</name>
          <group>
            <name>MC1322x</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\portable\IAR\MC1322x\ISR_Support.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\portable\IAR\MC1322x\port.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\portable\IAR\MC1322x\portasm.s79</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\portable\IAR\MC1322x\portmacro.h</name>
            </file>
          </group>
        </group>
        <group>
          <name>MemMang</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\portable\MemMang\heap_1.c</name>
          </file>
        </group>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\croutine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\FreeRTOS\Source\tasks.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>PLM</name>
    <group>
      <name>FlashLoader</name>
    </group>
    <group>
      <name>Interface</name>
      <file>
        <name>$PROJ_DIR$\..\PLM\Interface\PortConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\PLM\Interface\UART_Interface.h</name>
      </file>
    </group>
    <group>
      <name>Lib</name>
      <file>
        <name>$PROJ_DIR$\..\PLM\Lib\LLC.a</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <group>
        <name>Common</name>
        <group>
          <name>Sys</name>
          <file>
            <name>$PROJ_DIR$\..\PLM\Source\Common\Sys\Init-IAR.S</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\PLM\Source\Common\Sys\PlatformInit.c</name>
          </file>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>SMAC</name>
    <group>
      <name>Drivers</name>
      <group>
        <name>Interface</name>
        <file>
          <name>$PROJ_DIR$\..\SMAC\Drivers\Interface\Delay.h</name>
        </file>
      </group>
      <group>
        <name>Lib</name>
        <file>
          <name>$PROJ_DIR$\..\SMAC\Drivers\Lib\MC1322x.a</name>
        </file>
      </group>
      <group>
        <name>Source</name>
        <file>
          <name>$PROJ_DIR$\..\SMAC\Drivers\Source\Delay.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\SMAC\Drivers\Source\maca.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\SMAC\Drivers\Source\MacaInterrupt.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\SMAC\Source\HLDrv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SMAC\Source\RadioManagement.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SMAC\Source\SecurityMngmnt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SMAC\Source\TransceiverConfigMngmnt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SMAC\Source\TransceiverPowerMngmnt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\SMAC\Source\WirelessLinkMngmt.c</name>
      </file>
    </group>
  </group>
</project>


